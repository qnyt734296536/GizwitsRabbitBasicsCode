# Keil uVision project GizwitsRabbitBoardTest.uvprojx, settings and files
target GizwitsRabbitBoardTest (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GizwitsRabbitBoardTest +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;      ..\Gizwits;      ..\Hal;      ..\Utils;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Hal
    ../Hal/: hal_key.c Hal_Buzzer.c Hal_Inf_Receiver.c Hal_Infrared_Tube.c Hal_Led.c Hal_Light_Resistor.c Hal_Pyr.c Hal_Relay.c Hal_Rgb_My9291.c Hal_Temp_Hum.c Hal_Dcout.c Hal_Oled.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c delay.c
  group Application/User
    ../Src/: user_pro_eint.c main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
